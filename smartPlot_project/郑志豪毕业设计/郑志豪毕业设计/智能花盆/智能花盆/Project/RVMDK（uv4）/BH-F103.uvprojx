# Keil uVision project BH-F103.uvprojx, settings and files
target 安防 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: OV7725 +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\delay;..\..\User\onenet\inc;..\..\User\device\inc;..\..\User\EDP;..\..\User\onenet\inc;..\..\User\hwtimer;..\..\User\dht11;..\..\User\warning;..\..\User\beep;..\..\User\adc;..\..\User\IIC;..\..\Freee-RTOS\include;..\..\Freee-RTOS\portable\RVDS\ARM_CM3;..\..\User\IWDG;..\..\User\soil_H;..\..\User\BH1750;..\..\User\water;..\..\User\light_moto
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_adc.c
  group USER
    ../../User/: main.c stm32f10x_it.c
    ../../User/usart/: bsp_usart.c
    ../../User/SysTick/: bsp_SysTick.c
    ../../User/device/src/: esp8266.c
    ../../User/delay/: delay.c
    ../../User/hwtimer/: hwtimer.c
    ../../User/beep/: beep.c
    ../../User/IIC/: IIC.c
  group DOC
    ../../Doc/: readme.txt
  group net_protocol
    ../../User/EDP/: EdpKit.c
  group One_net
    ../../User/onenet/src/: onenet.c
  group Sensor
    ../../User/dht11/: dht11.c
    ../../User/warning/: warning.c
    ../../User/soil_H/: soil_H.c
    ../../User/BH1750/: BH1750.c
    ../../User/water/: water.c
    ../../User/light_moto/: light_moto.c
  group Free_RTOS
    ../../Freee-RTOS/: timers.c tasks.c queue.c list.c event_groups.c croutine.c
    ../../Freee-RTOS/portable/RVDS/ARM_CM3/: port.c
    ../../Freee-RTOS/portable/MemMang/: heap_4.c
