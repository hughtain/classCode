# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\User;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Libraries\CMSIS\CM3\CoreSupport;.\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\Public;.\App\led;.\UCOSIII\uC-BSP;.\UCOSIII\uC-CONFIG;.\UCOSIII\uC-CPU;.\UCOSIII\uC-LIB;.\UCOSIII\uCOS-III\Source;.\UCOSIII\uC-CPU\ARM-Cortex-M3\RealView;.\UCOSIII\uC-LIB\Ports\ARM-Cortex-M3\RealView;.\UCOSIII\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView;.\App\key;.\App\adc_temp;.\App\esp8266\ESP8266_drive;.\App\esp8266\ESP8266_Public;.\App\esp8266\STA_TCPClent_Test;.\App\low;.\App\DHT11;.\App\UnItdelay;.\App\HC-SR501;.\App\pwm;.\App\Lsen;.\App\mq2;.\App\tftlcd;.\App\machine
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./User/: main.c stm32f10x_it.c
  group Startup
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group CMSIS
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ./Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_fsmc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_dma.c
  group App
    ./App/led/: led.c
    ./App/key/: key.c
    ./App/adc_temp/: adc_temp.c
    ./App/low/: low.c
    ./App/DHT11/: dht11.c
    ./App/UnItdelay/: UnItdelay.c
    ./App/HC-SR501/: HC-SR501.c
    ./App/pwm/: pwm.c
    ./App/Lsen/: lsen.c
    ./App/mq2/: mq2.c
    ./App/tftlcd/: tftlcd.c
    ./App/machine/: machine.c
  group Public
    ./Public/: system.c SysTick.c usart.c
  group UCOSIII-BSP
    ./UCOSIII/uC-BSP/: bsp.c
  group UCOSIII-LIB
    ./UCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ./UCOSIII/uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group UCOSIII-CPU
    ./UCOSIII/uC-CPU/: cpu_core.c
    ./UCOSIII/uC-CPU/ARM-Cortex-M3/RealView/: cpu_a.asm cpu_c.c
  group UCOSIII-CORE
    ./UCOSIII/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c os.h os_type.h
  group UCOSIII-PORT
    ./UCOSIII/uCOS-III/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu.h os_cpu_a.s os_cpu_c.c
  group UCOSIII-CONFIG
    ./UCOSIII/uC-CONFIG/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group ESP8266
    ./App/esp8266/ESP8266_drive/: esp8266_drive.c
    ./App/esp8266/ESP8266_Public/: esp8266_public.c
    ./App/esp8266/STA_TCPClent_Test/: sta_tcpclent_test.c
